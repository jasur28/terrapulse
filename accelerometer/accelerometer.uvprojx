# Keil uVision project accelerometer.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: accelerometer
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c adxl345.c diskio.c ds1302.c ring_buffer.c sdcard.c uart_debug.c adxl345.h ds1302.h ffconf.h ring_buffer.h sdcard.h uart_debug.h diskio.h ff.c ff.h ffunicode.c
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
